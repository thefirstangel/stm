# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_IAR_Template
  ICCARM.CCIncludePath2: ..\LIB\inc; ..\Start; ..\System\delay; ..\System\usart; ..\System\sys; ..\System\oled12864\inc; ..\user
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.hex
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: ..\ICF\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration C8T6 Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103V8 ST STM32F103V8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; USE_IAR_Template
  ICCARM.CCIncludePath2: ..\LIB\inc; ..\Start; ..\System\delay; ..\System\usart; ..\System\sys; ..\System\oled12864\inc; ..\user; ..\System\UCOSII\CONFIG; ..\System\UCOSII\CORE; ..\System\UCOSII\PORT; ..\System\LED
  AARM.AUserIncludes: ..\System\UCOSII\PORT
  group CMSIS
    ../CMSIS/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s
  group LIB
    ../LIB/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Start
    ../Start/: stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c system_stm32f10x.h
  group System/delay
    ../System/delay/: delay.c delay.h
  group System/led
    ../System/LED/: led.c
  group System/oled
    ../System/oled12864/scr/: oled.c
  group System/UCOSII/Config
    ../System/UCOSII/CONFIG/: os_cfg.h
  group System/UCOSII/core
    ../System/UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group System/UCOSII/port
    ../System/UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group user
    ../user/: include.h main.c
